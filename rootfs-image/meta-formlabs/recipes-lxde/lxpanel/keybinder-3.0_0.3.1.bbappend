
SRC_URI = "https://github.com/kupferlauncher/keybinder/releases/download/keybinder-3.0-v0.3.1/keybinder-3.0-0.3.1.tar.gz"
