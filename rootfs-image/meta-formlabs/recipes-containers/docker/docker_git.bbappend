FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://docker-tty-enable-onlcr.patch"